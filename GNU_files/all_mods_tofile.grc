options:
  parameters:
    author: Barry Duggan
    description: NBFM transmitter
    generate_options: qt_gui
    id: NFM_xmt
    output_language: python
    title: NFM_xmt
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: fm_dev
  id: variable_qtgui_chooser
  parameters:
    label: FM Deviation Selector
    label0: Narrowband
    label1: Wideband
    num_opts: '2'
    option0: '2500'
    option1: '5000'
    orient: Qt.QHBoxLayout
    type: int
    value: '5000'
    widget: radio_buttons
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Audio gain
    start: '0'
    step: '0.1'
    stop: '10.0'
    value: '1.8'
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: audio_rate
    tau: '75e-6'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2 * math.pi * fm_dev) / audio_rate
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/garrett/Code/stdout.dat
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Audio gain
    const: volume
    type: float
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_0
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '2'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: '16000'
    fc: '0'
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [analog_fm_preemph_0, '0', analog_frequency_modulator_fc_0, '0']
- [analog_frequency_modulator_fc_0, '0', blocks_file_sink_0_0, '0']
- [analog_frequency_modulator_fc_0, '0', qtgui_sink_x_0_0, '0']
- [audio_source_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', analog_fm_preemph_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
